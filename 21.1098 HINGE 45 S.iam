# Autodesk Inventor assembly: 21.1098 HINGE 45 S
## iProperties
Created: 2012-04
Part Number: 21.1098 HINGE 45 S
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
